# Keil uVision project Bootloader.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00004000) IRAM2(0x20004000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1
  c include: ..\Drivers\Gpio_Driver;..\Drivers;..\Application;..\Base\Buffer\api;..\Base\ComIf\api;..\Base\Debug\api;..\Base\Buffer\src;..\Base\ComIf\src;..\Base\Debug\src;..\Gen;..\Base;..\Drivers\NVM;..\Drivers\NVS;..\Project
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  scatter file: .\Objects\Bootloader.sct
  group main
    ./: main.c
  group STM32_Driver
    ../Drivers/Gpio_Driver/: stm32h5xx_hal_gpio.c
    ../Drivers/: Ports_init.c Uart_Driver.c PLL_Driver.c Flash_Main.c Backup_ram.c
  group Application
    ../Application/: Boot_Transmit_uC_To_Tool.c Bootloader_Main.c Flowcontrol.c NvmNvs_state_Handling.c
  group COMIF_Files
    ../Base/Buffer/src/: Buffer.c
    ../Base/ComIf/src/: ComIf.c ComIf_CalcChecksum.c ComIf_RxIndication.c ComIf_RxRequest.c ComIf_Transmit.c ComIf_TxShadowBuffer.c
    ../Base/Debug/src/: Debug.c
  group Gen
    ../Gen/: Buffer_Config.c ComIf_Config.c
  group NVM
    ../Drivers/NVM/: NVM_Driver.c
  group NVS
    ../Drivers/NVS/: NVS_Driver.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.1.0
