# Keil uVision project Boot_manager.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IRAM2(0x20004000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Boot_manager +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c include: ..\Drivers\Gpio_Driver;..\Drivers;..\Application;..\Project;..\Drivers\NVM;..\Drivers\NVS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  scatter file: .\Objects\Boot_manager.sct
  group Source Group 1
    ./: main.c
  group STM32_Driver
    ../Drivers/: Backup_ram.c Flash_Main.c
    ../Drivers/Gpio_Driver/: stm32h5xx_hal_gpio.c
  group Application
    ../Application/: Jump_Boot_App.c Validate_file.c
  group NVM
    ../Drivers/NVM/: NVM.c NVM_Driver.c
  group NVS
    ../Drivers/NVS/: NVS.c NVS_Driver.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.1.0
